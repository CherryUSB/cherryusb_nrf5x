# Keil uVision project usbd_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEBUG DEBUG_NRF FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\drv\components;..\..\..\drv\components\drivers_nrf\nrf_soc_nosd;..\..\..\drv\components\libraries\atomic;..\..\..\drv\components\libraries\atomic_fifo;..\..\..\drv\components\libraries\balloc;..\..\..\drv\components\libraries\bsp;..\..\..\drv\components\libraries\button;..\..\..\drv\components\libraries\cli;..\..\..\drv\components\libraries\cli\uart;..\..\..\drv\components\libraries\delay;..\..\..\drv\components\libraries\experimental_section_vars;..\..\..\drv\components\libraries\hardfault;..\..\..\drv\components\libraries\hardfault\nrf52;..\..\..\drv\components\libraries\log;..\..\..\drv\components\libraries\log\src;..\..\..\drv\components\libraries\memobj;..\..\..\drv\components\libraries\mutex;..\..\..\drv\components\libraries\pwr_mgmt;..\..\..\drv\components\libraries\queue;..\..\..\drv\components\libraries\ringbuf;..\..\..\drv\components\libraries\scheduler;..\..\..\drv\components\libraries\sortlist;..\..\..\drv\components\libraries\strerror;..\..\..\drv\components\libraries\timer;..\..\..\drv\components\libraries\util;..\..\..;..\..\..\drv\external\fprintf;..\..\..\drv\integration\nrfx;..\..\..\drv\integration\nrfx\legacy;..\..\..\drv\modules\nrfx;..\..\..\drv\modules\nrfx\drivers\include;..\..\..\drv\modules\nrfx\hal;..\config;..\..\..\drv\modules\nrfx\drivers\src;..\..\..\drv\components\libraries\uart;..\..\..\drv\components\libraries\fifo;..\..\..\CherryUSB\common;..\..\..\CherryUSB\class\msc;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\core;..\..\..\CherryUSB;..\..\..\drv\components\boards
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG,-DDEBUG_NRF,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fnmatch;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
    ../../../CherryUSB/demo/: hid_keyboard_template.c hid_mouse_template.c msc_ram_template.c hid_custom_keyboard_template.c cdc_acm_template.c
  group nRF_Drivers
    ../../../drv/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../../../drv/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_systick.c nrfx_gpiote.c nrfx_power.c
    ../../../drv/modules/nrfx/soc/: nrfx_atomic.c
    ../../../drv/components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c nrf_nvic.c
    ../../../drv/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../drv/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../drv/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../drv/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../drv/components/libraries/hardfault/: hardfault_implementation.c
    ../../../drv/components/libraries/atomic/: nrf_atomic.c
    ../../../drv/components/libraries/balloc/: nrf_balloc.c
    ../../../drv/components/libraries/cli/: nrf_cli.c
    ../../../drv/components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../drv/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../drv/components/libraries/memobj/: nrf_memobj.c
    ../../../drv/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../drv/components/libraries/queue/: nrf_queue.c
    ../../../drv/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../drv/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../drv/components/libraries/sortlist/: nrf_sortlist.c
    ../../../drv/components/libraries/strerror/: nrf_strerror.c
    ../../../drv/components/libraries/uart/: app_uart.c app_uart_fifo.c retarget.c
    ../../../drv/components/libraries/fifo/: app_fifo.c
    ../../../drv/components/libraries/atomic_fifo/: nrf_atfifo.c
  group nRF_Log
    ../../../drv/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group CherryUSB
    ../../../CherryUSB/core/: usbd_core.c
    ../../../CherryUSB/class/msc/: usbd_msc.c
    ../../../CherryUSB/class/cdc/: usbd_cdc.c
    ../../../CherryUSB/class/hid/: usbd_hid.c
    ../../../CherryUSB/port/nrf5x/: usb_dc_nrf5x.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
